# Keil uVision project EthernetDemo.uvprojx, settings and files
target EthernetDemoTarget (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EthernetDemo
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ./: stm32f4xx_it.c main.c stm32f4xx_hal_msp.c DACFIFO.c PacketAssembler.c
  group DAC Queue
    ./: GPIOModule.c DACTimer.c DACModule.c DACModule.h
  group RTOS Objects
    ./: USBD_User_CDC_0.c TCPThread.c
  group CNC
    ./: CNCLerp.c
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2, CMSIS:RTOS:Keil RTX 4.75.0, Network:CORE 6.2.0, Network:Interface:ETH 6.2.0, Network:Socket:TCP 6.2.0, USB:CORE 6.2.0, USB:Device 6.2.0, USB:Device:CDC 6.2.0, CMSIS Driver:Ethernet MAC 2.6, CMSIS Driver:Ethernet PHY:LAN8720 6.00, CMSIS Driver:USART 2.7, CMSIS Driver:USB Device:Full-speed 2.15, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DAC 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:TIM 1.5.0, Device:STM32Cube HAL:UART 1.5.0, Device:STM32Cube HAL:USART 1.5.0, Device:Startup 2.5.0
